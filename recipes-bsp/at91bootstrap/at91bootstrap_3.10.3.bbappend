# Customization of at91boostrap 3.10.3

# Declare more compatible machines
COMPATIBLE_MACHINE .= "|arietta-g25|arietta-g25-256"
